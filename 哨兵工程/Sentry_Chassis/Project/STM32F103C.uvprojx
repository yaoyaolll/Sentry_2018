# Keil uVision project STM32F103C.uvprojx, settings and files
target MotorDriver (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,ARM_MATH_CM3
  c include: ..\Libraries;..\CM3;..\User;..\Hardware;..\Hardware\Task;..\Hardware\MYLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3
    ../CM3/: system_stm32f10x.c core_cm3.c startup_stm32f10x_md.s
  group Libraries
    ../Libraries/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_crc.c
  group User
    ../User/: stm32f10x_it.c main.c
  group MyLib
    ../Hardware/MYLIB/: can.c usart1.c usart2.c usart3.c encoder.c limit_switch.c CRC_algorithm.c friction_wheel.c led.c pid.c tim2.c
  group Task
    ../Hardware/TASK/: motor_task.c control_task.c data_rec_task.c data_send_task.c kalman_filter.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
